v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {ipin.sym} -310 -40 0 0 {name=p1 lab=vbias1}
C {ipin.sym} -310 40 0 0 {name=p2 lab=vbias2}
C {opin.sym} -230 50 0 0 {name=p3 lab=vinp2}
C {opin.sym} -230 -40 0 0 {name=p4 lab=vinp1}
